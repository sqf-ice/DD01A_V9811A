# Keil uVision project DI03B_9811A_V10.uvproj, settings and files
target DI03B_9811A_V10 (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: DI03B_9811A_V10 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\C_Source\S0_System;..\C_Source\S1_HardDrv;..\C_Source\S2_MyLib;..\C_Source\S3_ApiPlat;..\C_Source\S4_ApiUser;..\C_Source\S5_ApiProtocol;..\C_Source\S6_MyIncludes;..\C_Source\S1_HardDrv\V9811A_EMU;..\C_Source\S1_HardDrv\V9811A_MCU;..\C_Source\S1_HardDrv\E2P_24CXXX
  group START_BOOT
    ../C_Source/: STARTUP.A51
  group S0_System
    ../C_Source/S0_System/: main.c Proc_Data.c Proc_EXmem.c Proc_System_Check.c Proc_System_Initialize.c Proc_System_Interrupt.c Proc_System_Tou.c
  group S1_HardDrv
    ../C_Source/S1_HardDrv/E2P_24CXXX/: Drv_E2P_24CXXX.c Drv_E2P_i2cSoft.c
    ../C_Source/S1_HardDrv/V9811A_EMU/: Drv_EMU_hard.c Lnk_EMU_Adj.c Lnk_EMU_handl.c
    ../C_Source/S1_HardDrv/V9811A_MCU/: Drv_ADC.c Drv_core.c Drv_GPIO.c Drv_KEY_IO.c Drv_LCD.c Drv_RTC.c Drv_TMR.c Drv_UART.c
  group S2_MyLib
    ../C_Source/S2_MyLib/: Lib_myMath.c Lib_mySpring.c Lib_myTimer.c
  group S3_ApiPlat
    ../C_Source/S3_ApiPlat/: Api_AdjErr.c Api_Bill_Record.c Api_Demand.c Api_Energy.c Api_Event.c Api_LoadProfile.C Api_Measure.c Api_Triff.c API_Relay.c
  group S4_ApiUser
    ../C_Source/S4_ApiUser/: Api_Lcd_Display.c Api_User_Comm.c
  group S5_ApiProtocol
    ../C_Source/S5_ApiProtocol/: IEC62056_21.c
  group S6_MyIncludes
    ../C_Source/S6_MyIncludes/: dw8051.h LeoPartReg.h MyIncludes_H.h reg52.h SYS_Config_H.h SYS_DATA_MACRO_H.h SYS_IOdefine_H.h SYS_MCU_MACRO_H.h SYS_typedef_H.h
